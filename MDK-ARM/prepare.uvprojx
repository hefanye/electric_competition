# Keil uVision project prepare.uvprojx, settings and files
target prepare (6180000::V6.18::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: prepare +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../User;../User/UI;../User/tests;../User/algorithm/filter;../User/algorithm/measure;../User/algorithm/signal_process;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dac.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/App
    ../User/: screen_protocol.c dds_at.c dds_ui.c adc_baseline_test.c
  group Application/User/G_UI
    ../User/UI/: ui_controller.c ui_demo_data.c ui_display.c ui_plot.c
  group Application/User/DAC8830
    ../User/: dac8830.c dac8830_cli.c
  group Application/User/AD9226
    ../User/: g_signal_measurement.c ad9226_debug_nogain.c g_signal_pc_debug.c
  group Application/User/ADC_Internal
    ../User/: adc_internal_debug.c
  group Application/User/NRF24L01
    ../User/: nrf24l01.c nrf_bridge.c
  group Application/User/Tests
    ../User/tests/: algorithm_test_common.c algorithm_test.c test_moving_average.c test_median.c test_one_pole_lpf.c test_dc_blocker.c test_biquad.c test_statistics.c test_amplitude.c test_frequency.c test_phase.c test_signal_quality.c test_stability.c test_calibration.c test_window_functions.c test_fft_spectrum.c test_goertzel.c test_nco.c test_sweep_planner.c test_am_envelope.c test_fsk.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Algorithm/Filter
    ../User/algorithm/filter/: biquad_filter.c dc_blocker.c median_filter.c moving_average.c one_pole_lpf.c
  group Algorithm/Measure
    ../User/algorithm/measure/: amplitude_measurement.c calibration.c frequency_measurement.c phase_measurement.c signal_quality.c stability_detector.c statistics.c
  group Algorithm/SignalProcess
    ../User/algorithm/signal_process/: am_envelope.c fft.c fsk_detector.c goertzel.c nco.c spectrum_analysis.c sweep_planner.c window_functions.c
software components: CMSIS:CORE 5.6.0
